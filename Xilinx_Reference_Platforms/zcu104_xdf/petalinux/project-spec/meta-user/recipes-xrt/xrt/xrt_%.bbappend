SRCREV = "${AUTOREV}"

#inherit externalsrc
#EXTERNALSRC = "/proj/xsjhdstaff1/minm/XRTs/XRT_xocl/src"
#EXTERNALSRC_BUILD = "${WORKDIR}/build"
