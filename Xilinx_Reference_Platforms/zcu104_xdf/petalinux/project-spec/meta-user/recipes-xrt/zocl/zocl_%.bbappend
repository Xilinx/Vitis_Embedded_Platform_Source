# Use latest version
SRCREV = "${AUTOREV}"

#inherit externalsrc
#EXTERNALSRC = "/proj/xsjhdstaff1/minm/XRTs/XRT_xocl/src/runtime_src/core/edge/drm/zocl"
#EXTERNALSRC_BUILD = "/proj/xsjhdstaff1/minm/XRTs/XRT_xocl/src/runtime_src/core/edge/drm/zocl"
