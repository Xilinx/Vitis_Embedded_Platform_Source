SRC_URI += "file://user_2019-04-13-15-56-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

