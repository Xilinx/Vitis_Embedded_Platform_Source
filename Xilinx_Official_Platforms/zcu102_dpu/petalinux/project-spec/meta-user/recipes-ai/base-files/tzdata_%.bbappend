FILES_${PN} += "${datadir}/zoneinfo/Asia/Shanghai"
