RDEPENDS_${PN}_append = " \
	nativesdk-protobuf \
	nativesdk-protobuf-c \
	nativesdk-protobuf-compiler \
	nativesdk-protobuf-dev \
	nativesdk-make \
"
