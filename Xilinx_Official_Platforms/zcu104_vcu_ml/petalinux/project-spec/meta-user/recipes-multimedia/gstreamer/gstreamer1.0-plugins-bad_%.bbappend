FILESEXTRAPATHS_prepend := "${THISDIR}/gstreamer1.0-plugins-bad:"

