FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append ="\
    file://system-user.dtsi \
    file://pl.dtsi \
"
