FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
	    file://pl.dtsi \
	    file://system-user.dtsi \
	    "
