FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-transform_meta-in-v4l2transform-plugin.patch"

