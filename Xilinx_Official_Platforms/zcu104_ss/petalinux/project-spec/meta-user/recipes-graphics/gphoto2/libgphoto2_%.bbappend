do_install_append() {
	rm ${D}${includedir}/gphoto2/gphoto2
}
