SRC_URI_append = " \
       file://0001-include-privates.h-Exit-if-key-is-not-initialized.patch \
"


FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

