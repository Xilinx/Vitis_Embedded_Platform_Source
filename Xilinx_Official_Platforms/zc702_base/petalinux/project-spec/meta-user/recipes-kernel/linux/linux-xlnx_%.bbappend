SRC_URI += "file://bsp.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://user.cfg"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
